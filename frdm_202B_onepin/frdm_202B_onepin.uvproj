# Keil uVision project frdm_202B_onepin.uvproj, settings and files
target mbed FRDM-KL46Z (ARM-ADS)
  device: MKL46Z256xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: frdm_202B_onepin
  AfterMake: fromelf --bin -o build\frdm_202B_onepin_KL25Z.bin build\frdm_202B_onepin.axf
  c flags: Optim=1
  c define: TARGET_KL46Z,  TARGET_M0P,  TARGET_CORTEX_M,  TARGET_Freescale,  TARGET_KLXX,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0PLUS,  ARM_MATH_CM0PLUS,  MBED_BUILD_TIMESTAMP=1434435211.99,  __MBED__=1,  TARGET_FF_ARDUINO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  SLCD;  mbed;  mbed/TARGET_KL46Z;  mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD;  mbed/TARGET_KL46Z/TARGET_Freescale;  mbed/TARGET_KL46Z/TARGET_Freescale/TARGET_KLXX;  mbed/TARGET_KL46Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL46Z;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/MKL46Z4.sct
  link misc: mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/startup_MKL46Z4.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/system_MKL46Z4.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
    SLCD/: SLCD.cpp
